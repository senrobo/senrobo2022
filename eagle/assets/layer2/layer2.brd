File: eagle/assets/layer2/layer2.brd (EAGLE design)
At the start: 160 x 100 mm, 1 part

Commit message: -
Other:
- board size 160 x 100 mm -> 196 x 185.3 mm
